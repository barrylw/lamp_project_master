# IAR project MasterNode.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER; USE_LORA_MODE
  ICCARM.CCDiagSuppress: Pa25
  ICCARM.CCIncludePath2: APP; LIB\CMSIS\CM3\DeviceSupport\ST\STM32F10x; LIB\STM32F10x_StdPeriph_Driver\inc; core; core\sys; platform; core\lib; tools\wpcapslip; core\cfs; coffee_arch
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MasterNode.hex
  ILINK.IlinkOutputFile: MasterNode.out
  ILINK.IlinkIcfFile: ICF\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    platform/: clock.c
    APP/: Cmd.c Comm.c Delay.c Flash.c FRAM.c General.c hal_radio.c hal_Random.c Init.c Led.c MAC.c Main.c MCP.c Mem.c Memory.c PHY.c Radio.c Rtc.c stm32f10x_conf.h stm32f10x_it.c Str.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-LoRa.c sx1276-LoRaMisc.c Sys.c Tim.c Uart.c
  group contiki/coffee
    coffee_arch/: cfs-coffee-arch.c
    core/cfs/: cfs-coffee.c
  group contiki/lib
    core/lib/: checkpoint.c crc16.c ifft.c list.c memb.c mmem.c print-stats.c random.c ringbuf.c settings.c trickle-timer.c
  group contiki/loder
    core/loader/: elfloader.c
  group contiki/sys
    core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c process.c procinit.c profile.c rtimer.c stimer.c timer.c timetable-aggregate.c
  group LIB/CM3
    LIB/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: startup_stm32f10x_hd.s system_stm32f10x.c
  group LIB/PER
    LIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group OS
    OS/: os_cpu_a.asm
