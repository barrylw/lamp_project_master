# IAR project Backup of MasterNode.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa039
  ICCARM.CCIncludePath2: APP\; LIB\STM32F10x_StdPeriph_Driver\inc; LIB\CMSIS\CM3\DeviceSupport\ST\STM32F10x; LIB\CMSIS\CM3\Core
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MasterNode.hex
  ILINK.IlinkOutputFile: MasterNode.out
  ILINK.IlinkIcfFile: ICF\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    APP/: Cmd.c Comm.c Delay.c Flash.c General.c hal_radio.c Init.c Led.c MAC.c Main.c MCP.c Mem.c Memory.c PHY.c Radio.c Random.c Rtc.c stm32f10x_conf.h stm32f10x_it.c Str.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-LoRa.c sx1276-LoRaMisc.c sx1276.c Sys.c Tim.c Uart.c
  group LIB/CM3
    LIB/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: startup_stm32f10x_hd.s system_stm32f10x.c
  group LIB/PER
    LIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group OS
    OS/: os_cpu_a.asm
